# Keil uVision project Expt1_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: LC80-SR8051 Sanyo
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: Expt1_lcd
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
